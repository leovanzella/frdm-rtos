# Keil uVision project FRDM_RTOS.uvproj, settings and files
target FDRM_RTOS (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: FRDM_RTOS
  c flags: Optim=1
  c include: .;.\FreeRTOS-Source\include;.\FreeRTOS-Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group Startup
    ./: startup_MKL25Z4.s
  group Source Files
    ./: main.c
  group Documentation
    ./: Abstract.txt
  group FreeRTOS-Source
    ./FreeRTOS-Source/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS-Source/: list.c queue.c tasks.c
    ./FreeRTOS-Source/portable/MemMang/: heap_1.c
target ULink-MTB (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
target ULinkPro-MTB (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
